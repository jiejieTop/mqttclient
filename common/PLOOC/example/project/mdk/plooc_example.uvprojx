# Keil uVision project plooc_example.uvprojx, settings and files
target arm_compiler_6_example (6150000::V6.15.0.1 dev::.\ARMCompiler6.15)
  device: CMSDK_CM3 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: plooc_example
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: _MSC_VER __OOC_DEBUG__
  c misc: -fms-extensions -Wno-microsoft-anon-tag -Wno-empty-body
  c include: ..\mdk;..\..\..\example;..\..\..\..\PLOOC
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  group platform
    ./: platform.c platform.h
    ../: main.c
  group PLOOC
    ../../../: plooc.h plooc_class.h plooc_class_strict.h plooc_class_black_box.h plooc_class_simple.h
  group byte_queue
    ../../byte_queue/: byte_queue.h byte_queue.c
  group enhanced_byte_queue
    ../../enhanced_byte_queue/: enhanced_byte_queue.c enhanced_byte_queue.h
  group trace
    ../../trace/: trace.h trace.c
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0
